# Keil uVision project autosartest.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: autosartest
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: bitwise_operations.h Dio_Cfg.h Dio_LCfg.c Dio_LCfg.h Dio_Types.h main.c Port_Cfg.h Port_LCfg.c Port_LCfg.h Port_Types.h tm4c123gh6pm.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.1
